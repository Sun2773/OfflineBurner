# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10x
  ICCARM.CCIncludePath2: ..; ..\Arithmetic; ..\Arithmetic\MSC\inc; ..\Arithmetic\SWD; ..\Arithmetic\algo; ..\Board; ..\Chip; ..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Library\CMSIS-DAP\Config; ..\Library\CMSIS-DAP\Include; ..\Library\STM32F10x_StdPeriph_Driver\inc; ..\Library\STM32_USB-FS-Device_Driver\inc; ..\Library\FATFS; ..\Library\cJson; ..\Task; ..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\User
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: python ..\Script\post-build.py $CONFIG_NAME$ $TARGET_DIR$ $TARGET_BNAME$ $PROJ_DIR$ $PROJ_FNAME$
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\User\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Bootloader (ARM)
  as the first configuration, except:
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10x; RELEASE
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.hex
  group (top)
    ../: FlashLayout.h Version.h
  group .Task
    ../Task/: Task_Burner.c Task_Burner.h Task_Key.c Task_Key.h Task_Led.c Task_Led.h Task_USB.c Task_USB.h
  group Arithmetic
    ../Arithmetic/: BurnerConfig.c BurnerConfig.h crc.c crc.h heap.c heap.h
  group Arithmetic/algo
    ../Arithmetic/algo/: flash_blob.c flash_blob.h
  group Arithmetic/algo/STM32F0
    ../Arithmetic/algo/STM32F0/: STM32F0xx_256_2K.c STM32F0xx_64.c STM32F0xx_OPT.c
  group Arithmetic/algo/STM32F1
    ../Arithmetic/algo/STM32F1/: STM32F10x_1024.c STM32F10x_128.c STM32F10x_512.c STM32F10x_OPT.c
  group Arithmetic/algo/STM32F2
    ../Arithmetic/algo/STM32F2/: STM32F2xx_1024.c STM32F2xx_OPT.c
  group Arithmetic/algo/STM32F3
    ../Arithmetic/algo/STM32F3/: STM32F3xx_512.c STM32F3xx_OPT.c
  group Arithmetic/algo/STM32F4
    ../Arithmetic/algo/STM32F4/: STM32F40xxx_41xxx_OPT.c STM32F4xx_1024.c
  group Arithmetic/MSC/inc
    ../Arithmetic/MSC/inc/: hw_config.h mass_mal.h memory.h usb_bot.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h usb_scsi.h
  group Arithmetic/MSC/src
    ../Arithmetic/MSC/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Arithmetic/SWD
    ../Arithmetic/SWD/: SWD_flash.c SWD_flash.h SWD_host.c SWD_host.h
  group Board
    ../Board/: buzzer.c buzzer.h Key.c Key.h led.c led.h SPI_Flash.c SPI_Flash.h
  group Chip
    ../Chip/: spi.c spi.h
  group Library/cJson
    ../Library/cJson/: cJSON.c cJSON.h
  group Library/CMSIS
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h
  group Library/CMSIS-DAP/Config
    ../Library/CMSIS-DAP/Config/: DAP_config.h
  group Library/CMSIS-DAP/Include
    ../Library/CMSIS-DAP/Include/: DAP.h
  group Library/CMSIS-DAP/Source
    ../Library/CMSIS-DAP/Source/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c
  group Library/FATFS
    ../Library/FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffext.c ffext.h ffsystem.c ffunicode.c
  group Library/STM32_USB-FS-Device_Driver/inc
    ../Library/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group Library/STM32_USB-FS-Device_Driver/src
    ../Library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Library/STM32F10x_StdPeriph_Driver/inc
    ../Library/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_dac.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
  group Library/STM32F10x_StdPeriph_Driver/src
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: bootloader.c main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
